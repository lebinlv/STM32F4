# Keil uVision project E_Ink.uvprojx, settings and files
target E-Ink (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Include;..\Library\inc;..\USER;..\CMSIS;..\System;..\HardWare
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c system_stm32f4xx.c
  group HardWare
    ../HardWare/: E_LINK.c E_LINK_Display.c font8.c font12.c font16.c font20.c font24.c IMAGE.c led.c
  group SYSTEM
    ../System/: delay.c
  group Library
    ../Library/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group CMSIS
    ../CMSIS/StartUP/: startup_stm32f40_41xxx.s
